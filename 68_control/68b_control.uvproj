# Keil uVision project 68b_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5268B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000)
  output: 68b_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51
    ./code(68b)/: buzz.c display.c init.c isr.c keys.c main.c tempAd.c triac.c
